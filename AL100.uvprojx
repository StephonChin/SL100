# Keil uVision project AL100.uvprojx, settings and files
target AL100 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: Mini58FDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: AL100 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\UserAPP\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group Src
    ./UserAPP/Src/: BT_Control.c Config.c Data_Process.c Flash_Prgm.c Key_Scan.c Led.c USART.c WifiBt.c Music.c
  group Inc
    ./UserAPP/Inc/: BT_Control.h Config.h Data_Process.h Flash_Prgm.h Key_Scan.h Led.h Mini58Series.h TypeDef.h USART.h WifiBt.h Music.h
software components: CMSIS:CORE 5.0.2, Device:Driver:ADC 3.00.003, Device:Driver:CLK 3.00.003, Device:Driver:FMC 3.00.003, Device:Driver:GPIO 3.00.003, Device:Driver:Timer 3.00.003, Device:Driver:UART 3.00.003, Device:Driver:WDT 3.00.003, Device:Startup 3.00.003
